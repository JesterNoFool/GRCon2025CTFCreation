options:
  parameters:
    author: Gary Schafer
    comment: |-
      This flowgraph combines two audio
      signals (a baseband and subcarrier)
      to create an audio signal for a
      ATSC audio track. The audio signals
      were created in Audacity.
    generate_options: qt_gui
    id: atscMasterChannel1Audio
    output_language: python
    title: Master Flowgraph to Create Audio Track for ATSC Channel 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Frequency modulate the
      subcarrier audio.

      Sensitivity: 2*math.pi*3000/48e3
    sensitivity: 2*math.pi*3000/48e3
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency shift subcarrier

      Phase Increment:
      2*math.pi*17496.7/48e3
    phase_inc: 2*math.pi*17496.7/48e3
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: Channel-1-full-audio-track-48K0FS.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: channel-1-baseband-audio.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: Flag-4-audio-48K0FS.wav
    repeat: 'False'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '0.2'
    samp_rate: 48e3
    type: ccc
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 14e3
    decim: '1'
    gain: '0.7'
    samp_rate: 48e3
    type: fff
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4800'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [blocks_wavfile_source_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_rotator_cc_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
