options:
  parameters:
    author: Gary Schafer
    comment: |-
      The method to create a
      LSB signal is to first
      create a USB signal as a
      complex signal, then
      use the complex conjugate
      to flip the spectrum such
      that it is a LSB signal.
    generate_options: qt_gui
    id: challengeAmLsb
    output_language: python
    title: AM-LSB-SC Challenge Signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    comment: |-
      Convert USB signal
      to LSB signal.
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Challenge-AM-LSB-SC-1M0FS-30sec.cf32
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(30e6)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.19'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: flag9-audio-48K0FS-15sec-mono.wav
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: Filter the audio signal.
    decim: '1'
    taps: firdes.band_pass(1,48e3,300,5000,1000,5)
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: Create USB signal.
    num_taps: '480'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: lsbSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: lsbSignal
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', virtual_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
