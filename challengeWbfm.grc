options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: makeFmBroadcastSignalStereo
    output_language: python
    title: Make FM Broadcast Signal
  states: {}

blocks:
- name: lrminusAmp
  id: variable_qtgui_range
  parameters:
    comment: |-
      Set amplitude of 
      stereo L-R signal.
    label: L-R Amplitude
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.65'
  states: {}
- name: lrplusAmp
  id: variable_qtgui_range
  parameters:
    comment: |-
      Set amplitude of 
      baseband L+R
      signal.
    label: L+R Amplitude
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.89'
  states: {}
- name: pilotAmp
  id: variable_qtgui_range
  parameters:
    comment: |-
      Set amplitude of
      19 kHz pilot tone.
    label: Pilot Amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.09'
  states: {}
- name: rdsAmp
  id: variable_qtgui_range
  parameters:
    comment: |-
      Set amplitude of
      RDS subcarrier.
    label: RDS Amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scaAmp
  id: variable_qtgui_range
  parameters:
    comment: |-
      Set amplitude of
      SCA subcarrier.
    label: SCA Amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Frequency modulate
      the baseband audio
    sensitivity: 2*np.pi*75e3/samp_rate
  states: {}
- name: analog_frequency_modulator_fc_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*np.pi*5e3/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: pilotAmp
    comment: 19 kHz pilot tone
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: rdsAmp
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: scaAmp
    freq: 67e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: |-
      Create composite 
      baseband signal.
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    comment: Create L+R
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Challenge-WBFM-1M0FS-30sec.cf32
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(30e6)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lrplusAmp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-lrminusAmp'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Set amplitude for
      combined FDM signal.
    const: '0.19'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '24'
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: Zeropad
    lengths: (24, 24)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Create L-R
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    comment: Turn into impulses
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: flag6-audio-48K0FS-15sec.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/GRCon2025/flag8-adolin-unoathed-48K0FS-15sec.wav
    repeat: 'True'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: Filter L channel
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: Filter R channel
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_3
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '30'
    ntaps: '151'
    samp_rate: 57e3
    sym_rate: '2375'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Create SCA subcarrier
    note: SCA
  states: {}
- name: note_1
  id: note
  parameters:
    comment: Create RDS subcarrier
    note: RDS
  states: {}
- name: note_2
  id: note
  parameters:
    comment: Create stereo signal
    note: Stereo
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/4
    color1: '"black"'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    grid: 'True'
    legend: 'False'
    size: '100000'
    srate: samp_rate
    tr_level: '1.1'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '57'
    interp: '1000'
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: '0.0'
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: KGR
    pty: '5'
    pty_locale: '1'
    radiotext: GRCon2025-flag7{shallan}
    ta: 'False'
    tp: 'True'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: scaSubcarrier
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: basebandAudio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: stereoSubcarrier
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: rdsSubcarrier
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: basebandAudio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rdsSubcarrier
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: stereoSubcarrier
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: scaSubcarrier
  states: {}

connections:
- [analog_fm_preemph_0, '0', blocks_add_xx_1, '0']
- [analog_fm_preemph_0, '0', blocks_sub_xx_0, '0']
- [analog_fm_preemph_0_0, '0', blocks_add_xx_1, '1']
- [analog_fm_preemph_0_0, '0', blocks_sub_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_frequency_modulator_fc_1, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_stream_mux_0, '0']
- [blocks_add_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_2, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_3, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_mux_0, '0', blocks_delay_0, '0']
- [blocks_stream_mux_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_sub_xx_0_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_wavfile_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '1', filter_fft_low_pass_filter_0_0, '0']
- [blocks_wavfile_source_1, '0', filter_fft_low_pass_filter_3, '0']
- [digital_diff_encoder_bb_0, '0', blocks_repeat_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_fm_preemph_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', analog_fm_preemph_0_0, '0']
- [filter_fft_low_pass_filter_3, '0', rational_resampler_xxx_0_0_0, '0']
- [filter_fft_rrc_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_frequency_modulator_fc_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0_0, '1']
- [rds_encoder_0, '0', digital_diff_encoder_bb_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_1, '0', blocks_add_xx_0, '3']
- [virtual_source_2, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_add_xx_0, '4']

metadata:
  file_format: 1
