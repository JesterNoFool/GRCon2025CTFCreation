options:
  parameters:
    category: Custom
    comment: |-
      This flowgraph takes a .TS file as
      input (MPEG2 transport stream)
      and converts it into an ATSC signal
      with a 10 MSps sample rate.
    generate_options: qt_gui
    id: challengeAtscSignal
    output_language: python
    title: Creation of ATSC Signal File
  states: {}

blocks:
- name: rrcTaps
  id: variable
  parameters:
    comment: 'Value: firdes.root_raised_cosine(0.11, symbol_rate, symbol_rate/2, 0.1152, 200)'
    value: firdes.root_raised_cosine(0.11, symbol_rate, symbol_rate/2, 0.1152, 200)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      Value: 
      2.25e6/143*684
    value: 2.25e6/143*684
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Challenge-Signal-ATSC-01.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '159999914'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '832'
    n: '1024'
    offset: '4'
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment:
      -math.pi/2
    phase_inc: '-math.pi/2'
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: np.nan
    filename: Challenge-Signal-ATSC
    sample_rate: 10e6
    type: real short (rc16_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: symbol_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: dtv_atsc_field_sync_mux_0
  id: dtv_atsc_field_sync_mux
  parameters: {}
  states: {}
- name: dtv_atsc_interleaver_0
  id: dtv_atsc_interleaver
  parameters: {}
  states: {}
- name: dtv_atsc_pad_0
  id: dtv_atsc_pad
  parameters: {}
  states: {}
- name: dtv_atsc_randomizer_0
  id: dtv_atsc_randomizer
  parameters: {}
  states: {}
- name: dtv_atsc_rs_encoder_0
  id: dtv_atsc_rs_encoder
  parameters: {}
  states: {}
- name: dtv_atsc_trellis_encoder_0
  id: dtv_atsc_trellis_encoder
  parameters: {}
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8VSB
    interpolation: INTERPOLATION_OFF
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: 'Taps: rrcTaps'
    decim: '1'
    taps: rrcTaps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import math'
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 10e6
    color1: '"black"'
    fc: '0'
    fftsize: '8192'
    legend: 'False'
    name: ATSC Signal
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '171'
    interp: '143'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '9'
    interp: '10'
    type: ccc
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_file_source_0, '0', dtv_atsc_pad_0, '0']
- [blocks_head_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_keep_m_in_n_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0, '0']
- [dtv_atsc_field_sync_mux_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_atsc_interleaver_0, '0', dtv_atsc_trellis_encoder_0, '0']
- [dtv_atsc_pad_0, '0', dtv_atsc_randomizer_0, '0']
- [dtv_atsc_randomizer_0, '0', dtv_atsc_rs_encoder_0, '0']
- [dtv_atsc_rs_encoder_0, '0', dtv_atsc_interleaver_0, '0']
- [dtv_atsc_trellis_encoder_0, '0', dtv_atsc_field_sync_mux_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_rotator_cc_0, '0']
- [fft_filter_xxx_0, '0', blocks_throttle_0, '0']
- [fft_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
