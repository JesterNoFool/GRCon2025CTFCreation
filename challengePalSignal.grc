options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: challengePalSignal
    output_language: python
    title: PAL Challenge Signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Frequency modulate
      the audio.

      Sensitivity:
      2*np.pi*50e3/200e3
    sensitivity: 2*np.pi*50e3/200e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-3'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Create a DC offset and
      make the polarity
      negative to conform
      with the PAL standard.
    const: '-0.7'
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    comment: |-
      Sum audio and
      video signal
      to create final
      PAL signal.
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    comment: |-
      Add Gaussian noise to
      make it more realistic.
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/GRCon2025/PAL-baseband-video-16M0FS.rs16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(240e6)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Set amplitude of audio
      carrier.
    const: '0.1'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Shift the USB so that
      the spectrum is inverted.

      Phase Increment:
      2*np.pi*(-11e3)/48e3
    phase_inc: 2*np.pi*(-11e3)/48e3
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Shift the spectrum of
      the signal so that it
      is contained within the
      center 8 MHz.
    phase_inc: 2*np.pi*-2.75e6/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Shift the FM signal to
      its final place in the
      spectrum.

      Phase Increment:
      2*np.pi*5.5e6/samp_rate
    phase_inc: 2*np.pi*5.5e6/samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Gary Schafer
    center_freq: np.nan
    filename: GRCon25-CTF-Please-Ask-Later
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Main audio
    file: /home/gary/SDR-Software/gnuradio/GRCon2025/PAL-audio.wav
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter to 8 MHz and
      decimate to 8 MSps.
    decim: '2'
    taps: firdes.low_pass(0.9,samp_rate,3.7e6,300e3,5)
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Filter the video signal
      to be contained within
      the required bandwidth
      and adjust the gain
      for modulation.
    cutoff_freq: 5e6
    decim: '1'
    gain: '0.88'
    samp_rate: samp_rate
    type: fff
    width: 200e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: Filter the audio.
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: Create an USB signal.
    num_taps: '4800'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 8e6
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '160000'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resample to 100 kHz
      for modulation.
    decim: '6'
    interp: '25'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '80'
    type: ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: videoSignal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: basebandAudio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: audioSignal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: palSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: basebandAudio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: videoSignal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: audioSignal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: palSignal
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', rational_resampler_xxx_0_1, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_3, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_head_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_2, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_rotator_cc_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_rotator_cc_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_add_xx_1, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0_1, '0', blocks_rotator_cc_0_0_0, '0']
- [virtual_source_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [virtual_source_1, '0', blocks_add_xx_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0_0, '1']
- [virtual_source_3, '0', blocks_head_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
