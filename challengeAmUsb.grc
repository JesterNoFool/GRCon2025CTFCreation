options:
  parameters:
    author: Gary Schafer
    comment: |-
      To create a USB signal, use
      the Hilbert transform to
      remove the lower sideband
      as a complex signal.
    generate_options: qt_gui
    id: challengeAmUsb
    output_language: python
    title: AM-USB-SC Challenge Signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gary/SDR-Software/gnuradio/GRCon2025/Challenge-AM-USB-SC-1M0FS-30sec.cf32
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: |-
      This will capture
      30 sec of signal
      at 1 MSps.
    num_items: int(30e6)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Adjust amplitude
      so that final, summed
      signal will not
      overload the final
      output.
    const: '0.19'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/GRCon2025/flag10-returnoftheheralds-48K0FS-30sec-mono.wav
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter audio to 300 - 5000

      Taps: firdes.band_pass(1,48e3,300,5000,1000,5)
    decim: '1'
    taps: firdes.band_pass(1,48e3,300,5000,1000,5)
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: |-
      Remove lower sideband
      (create single sideband)
    num_taps: '480'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Convert sample rate to final
      sample rate of 1 MHz in order
      to put all signals together
      into one file.
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
