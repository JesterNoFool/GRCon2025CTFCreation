options:
  parameters:
    author: Gary Schafer
    comment: |-
      This flowgraph creates an audio
      track for the second channel of
      the ATSC signal. It consists of a 
      baseband audio signal combined
      with a 2FSK subcarrier created
      from an ASCII text file.
    generate_options: qt_gui
    id: atscMasterChannel2Audio
    output_language: python
    title: Flowgraph to Create Audio Track 2 for ATSC Signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Create the FSK signal.

      Sensitivity: 
      2*math.pi*1500/48e3
    sensitivity: 2*math.pi*1500/48e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Create polar signal
      to NRZ.
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: flag5.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency shift the FSK
      subcarrier.

      Phase Increment:
      2*math.pi*17500/48e3
    phase_inc: 2*math.pi*17500/48e3
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Convert bytes to
      bits.
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: Channel-2-full-audio-track-48K0FS.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: channel-2-baseband-audio.wav
    repeat: 'False'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter the audio.

      Taps: firdes.low_pass(2,samp_rate,14e3,1e3,5)
    decim: '1'
    taps: firdes.low_pass(2,samp_rate,14e3,1e3,5)
    type: fff
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 2.0e3
    decim: '1'
    gain: '0.2'
    samp_rate: 48e3
    type: ccc
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import math'
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: Full Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_throttle_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
