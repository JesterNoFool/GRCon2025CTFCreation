options:
  parameters:
    author: gary
    comment: |-
      This flowgraph creates a NTSC
      video broadcast signal by
      combining a baseband NTSC
      video signal (created with hacktv)
      with two audio signals (a main
      and SAP subcarrier) created
      with Audacity.
    generate_options: qt_gui
    id: challengeNtscSignal
    output_language: python
    title: NTSC Challenge Signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 13.5e6
  states: {}
- name: sapFreq
  id: variable
  parameters:
    value: 2.25e6/143*5
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Frequency modulate the
      SAP audio.

      Sensitivity:
      2*np.pi*10e3/200e3
    sensitivity: 2*np.pi*10e3/200e3
  states: {}
- name: analog_frequency_modulator_fc_0_1
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Frequency modulate the
      main audio.

      Sensitivity:
      2*np.pi*25e3/200e3
    sensitivity: 2*np.pi*25e3/200e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-3'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Add the DC offset for the full
      carrier video, and invert the
      polarity.
    const: '-0.7'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    comment: |-
      Add Gaussian noise
      to make the signal
      appear more realistic.
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: NTSC-baseband-video.rs16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(240e6)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Set the amplitude of the
      audio with respect to
      the video carrier.
    const: '0.25'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency shift SAP signal.

      Phase Increment:
      2*np.pi*sapFreq/200e3
    phase_inc: 2*np.pi*sapFreq/200e3
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency shift the entire signal
      so that the NTSC signal is centered
      at 0.

      Phase Increment:
      2*np.pi*-1.75e6/samp_rate
    phase_inc: 2*np.pi*-1.75e6/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency shift audio signals
      to point 4.5 MHz from video
      carrier.

      Phase Increment:
      2*np.pi*4.5e6/samp_rate
    phase_inc: 2*np.pi*4.5e6/samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Gary Schafer
    center_freq: np.nan
    filename: GRCon2025-NTSC-Signal
    sample_rate: 8e6
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Main audio
    file: NTSC-audio-main.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: Subcarrier
    file: NTSC-subcarrier.wav
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter the entire signal to fit
      within the channel bandwidth
      (6 MHz). NOTE: The filter is
      actually just for the lower 
      sideband, as the upper sideband
      has already been filtered and
      the addition of the audio signals
      does not require extra
      filtering.
    decim: '1'
    taps: firdes.complex_band_pass(0.7,samp_rate,-2.5e6,5e6,500e3,5)
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Filter the video signal to the
      proper bandwidth for NTSC,
      and adjust the amplitude
      for the modulation.
    cutoff_freq: 4.2e6
    decim: '1'
    gain: '0.80'
    samp_rate: samp_rate
    type: fff
    width: 200e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_0_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 12e3
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '0.7'
    samp_rate: 200e3
    type: ccc
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 8e6
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '135000'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '135'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '27'
    interp: '16'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: videoSignal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audioSignals
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: audioShifted
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audioSignals
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: videoSignal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: audioShifted
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', filter_fft_low_pass_filter_1, '0']
- [analog_frequency_modulator_fc_0_1, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_add_xx_1, '0', blocks_head_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_head_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_2, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_rotator_cc_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [blocks_wavfile_source_0_0, '0', filter_fft_low_pass_filter_0_0_0, '0']
- [fft_filter_xxx_0, '0', rational_resampler_xxx_1, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [filter_fft_low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0, '0']
- [filter_fft_low_pass_filter_1, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0_1, '0']
- [rational_resampler_xxx_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_rotator_cc_0_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_add_xx_1, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_1, '0']
- [virtual_source_1, '0', blocks_add_xx_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0_0, '1']

metadata:
  file_format: 1
