options:
  parameters:
    author: gary
    generate_options: qt_gui
    id: challengeSignalCombo
    output_language: python
    title: Combine All SigID Signals Into One Spectrum
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-4'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '7'
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: DSB-FC
    file: GRCon2025/Challenge-AM-DSB-FC-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: DSB-SC
    file: Challenge-AM-DSB-SC-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    comment: NBFM
    file: Challenge-NBFM-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    comment: LSB
    file: Challenge-AM-LSB-SC-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    comment: WBFM
    file: Challenge-WBFM-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    comment: USB
    file: Challenge-AM-USB-SC-1M0FS-30sec.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(30e6)
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*48.48e3/samp_rate
    phase_inc: 2*np.pi*48.48e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*188.652e3/samp_rate
    phase_inc: 2*np.pi*188.652e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*-300e3/samp_rate
    phase_inc: 2*np.pi*-300e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0_1
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*107.96e3/samp_rate
    phase_inc: 2*np.pi*107.96e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0_2
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*-163.34e3/samp_rate
    phase_inc: 2*np.pi*-163.34e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_1
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Phase Increment: 
      2*np.pi*-2045/samp_rate
    phase_inc: 2*np.pi*-2045/samp_rate
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Gary Schafer
    center_freq: np.nan
    filename: GRCon25-CTF-SignalID-Flags6-13
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '6']
- [blocks_add_xx_0, '0', blocks_head_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_file_source_0, '0', blocks_rotator_cc_0_1, '0']
- [blocks_file_source_0_0, '0', blocks_rotator_cc_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_rotator_cc_0_0_1, '0']
- [blocks_file_source_0_1, '0', blocks_rotator_cc_0_0, '0']
- [blocks_file_source_0_1_0, '0', blocks_rotator_cc_0_0_2, '0']
- [blocks_file_source_0_2, '0', blocks_rotator_cc_0_0_0, '0']
- [blocks_head_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_0_0, '0', blocks_add_xx_0, '2']
- [blocks_rotator_cc_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_rotator_cc_0_0_1, '0', blocks_add_xx_0, '4']
- [blocks_rotator_cc_0_0_2, '0', blocks_add_xx_0, '5']
- [blocks_rotator_cc_0_1, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
